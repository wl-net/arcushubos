# Tag v1.8.3 is no longer reachable from master branch HEAD
SRC_URI = "git://github.com/lz4/lz4.git;protocol=https;nobranch=1 \
           file://run-ptest \
           "
